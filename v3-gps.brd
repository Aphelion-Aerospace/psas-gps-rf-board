# Repository Aphelion-Aerospace/psas-gps-rf-board (continued)

## EAGLE design v3-gps.brd (continued)

Parts:
C23, C27, C34, C35, C37: 100n; .0402-C-NOSILK
C28, C32: 22u; 1206-C
C36: 2.2u; .0603-B-NOSILK
C44: 1n 2kv; .0402-C-NOSILK
J3: ROCKETNET-CONNECTOR-16M; ROCKETNET-M-16
L1, L4: ACM2012; TDK-ACM2012
L3: HF70ACC201209-T; .0805-C-NOSILK
LED6: YLW; CHIPLED_0603
R10, R11: 75; 0402-C-NOSILK@1
R15: 6.49k; 0402-C-NOSILK@1
R17, R42, R43: 1k; 0402-C-NOSILK@1
T1, T2: ALT4532; TDK-ALT4532
TP16: TPTP06R; TP06R
TP22, TP26, TP32, TP33: TEST-POINT15MIL-TEST-POINT; 15MIL-TEST-POINT
U3: KSZ8081; QFN-24

Connections:
3.3VD: C27.2, C28.2, L3.2, R17.2, R42.1, R43.1, U3.14 (VDDIO); also elsewhere on the board
AUX1: J3.A1 (AUX1), TP22.P$1
AUX2: J3.A2 (AUX2), TP26.P$1
AUX3: J3.A3 (AUX3), TP32.P$1
AUX4: J3.A4 (AUX4), TP33.P$1
ETH_CRS_DV: U3.15 (CRS_DV/PHYADD); also elsewhere on the board
ETH_DEBUG: LED6.C, U3.23 (LED0/ANEN_SPEED); also elsewhere on the board
ETH_MCO1_CLK: U3.8 (XI); also elsewhere on the board
ETH_MDC: U3.11 (MDC); also elsewhere on the board
ETH_MDINT: R43.2, U3.18 (INTRP); also elsewhere on the board
ETH_MDIO: R42.2, U3.10 (MDIO); also elsewhere on the board
ETH_PHY_NRST: U3.24 (RST#); also elsewhere on the board
ETH_RMII_REF_CLK: U3.16 (REF_CLK); also elsewhere on the board
ETH_RXD0: U3.13 (RXD0); also elsewhere on the board
ETH_RXD1: U3.12 (RXD1); also elsewhere on the board
ETH_TXD0: U3.20 (TXD0); also elsewhere on the board
ETH_TXD1: U3.21 (TXD1); also elsewhere on the board
ETH_TX_EN: U3.19 (TXEN); also elsewhere on the board
GND: C23.2, C27.1, C28.1, C32.1, C34.1, C35.1, C36.2, C37.1, C44.1, J3.B-@1 (B-), J3.B-@2 (B-), R15.1, U3.22 (GND), U3.PAD (PAD_GND); also elsewhere on the board
unnamed: TP16.TP, U3.17 (RXER)
unnamed: J3.T+@13 (TX+), J3.T+@14 (TX+), L1.1
unnamed: C44.2, R10.1, R11.1
unnamed: J3.T-@9 (TX-), J3.T-@11 (TX-), L1.2
unnamed: LED6.A, R17.1
unnamed: C35.2, T1.3
unnamed: J3.R+@5 (RX+), J3.R+@7 (RX+), L4.1
unnamed: J3.R-@3 (RX-), J3.R-@4 (RX-), L4.2
unnamed: L1.4, T1.1
unnamed: L1.3, T1.2
unnamed: L4.4, T2.1
unnamed: L4.3, T2.2
unnamed: R11.2, T1.6
unnamed: R10.2, T2.6
unnamed: T2.4, U3.5 (TXM)
unnamed: T1.5, U3.4 (RXP)
unnamed: T2.5, U3.6 (TXP)
unnamed: R15.2, U3.9 (REXT)
unnamed: C37.2, T2.3
unnamed: T1.4, U3.3 (RXM)
VDDA_3.3: C32.2, C34.2, L3.1, U3.2 (VDDA_3.3)
VDD_1.2: C23.1, C36.1, U3.1 (VDD_1.2)
VIN: J3.B+@15 (B+), J3.B+@16 (B+); also elsewhere on the board

Notes on the sheet:
Common Mode Filters
Pulse Transformers
LINK/ACTIVITY
25 MHz from STM32
50 MHz to STM32 ETH
Ethernet PHY + RocketNet
STM32 RMII Interface

Board: 4 copper layers, 76.2 x 62.2 mm, 199 parts (0 on the bottom side), 150 nets.

## EAGLE design V1 GPS Filter and LNA Test Board.brd

Parts:
C1: 47 pF; C0402
C2: .1 uF; C0402
C3: 330 pF; C0402
J1, J2: CON_SMA-ENDFIRE_EMERSON_EMERSON-142-0701-801; SMA-CON-EMERSON
L1: 18nH; 0402-C
L2: 22nH; 0402-C
R1: 10; R0402
R2: 4.7k; R0402
U1: AVAGO-ALM-GPXX; AVAGO+SAW+LNA
X1: 332-02

Connections:
GND: C1.2, C2.2, C3.2, J1.GND, J1.GND@1 (GND), J1.GND@2 (GND), J1.GND@3 (GND), J2.GND, J2.GND@1 (GND), J2.GND@2 (GND), J2.GND@3 (GND), U1.2 (GND), U1.3 (GND), U1.4 (GND), U1.9 (GND), U1.P$1 (GND), U1.P$2 (GND), X1.1
unnamed: J1.SIG, U1.1 (RF-IN)
unnamed: L1.2, U1.7 (VDD)
unnamed: C3.1, L2.1, R1.1, R2.1, X1.2
unnamed: C1.1, C2.1, L1.1, L2.2, R1.2
unnamed: R2.2, U1.8 (SD)
unnamed: J2.SIG, U1.6 (RF-OUT)

Board: 2 copper layers, 50.5 x 25.4 mm, 11 parts (0 on the bottom side), 7 nets.

## Commit log

2013-04-16 Rewrote.
2013-04-17 Added STM32F407 144-pin footprint.
2013-04-17 Swapped for 144-pin STM32F4 and started schema changes.
2013-05-08 Added parts list for v1.
2013-07-21 Adding references.
2013-07-21 Remove file.
2013-09-22 Using 100-pin STM32F4 package. Moved existing peripherals over.
2013-09-28 Changed JTAG connector to standard 2x5 mini. Broke out GPIO and SPI lines to GPS chip. Added some testpoints. Added STM32F4 reset lines and hooked to JTAG.
2013-09-28 Added LEDs.
2013-09-28 Reconciled all ERC errors except for power/ground mismatches.
2013-09-29 Added testpoints. Verified pull-up and pull-down lines between STM32F4 and GPS chip. Verified Ethernet PHY circuit. Need Rocketnet connector info. ERC only complains about power/supply mismatch.
2013-09-29 Started replacing RJ-rt with 16-pin Rocketnet connector.
2013-10-04 Cosmetic changes. Waiting on design review with Andrew. Ethernet not entirely done.
2013-10-05 Reviewed with Andrew. Changed 2.2uF packages to 0603. Removed bootloader pins on stm32f4. Added some names. Removed R values on JTAG T lines as per working rocketnet hub circuit. Made USB power pin N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
2013-10-05 Found application circuit that does what we want and is OK for 4.5V-26V. Added backfeed protection from USB 5V input and connected to Rocketnet input. Added the linear regulator and LT4619 buck dc/dc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
2013-10-06 Added LEDs to linear regulator for 5V and 3.3VA. Made another pass over Ethernet. The only weird place left is in the PHY_CLK_25MHz and REF_CLK signals. Also need to compare gps chip analog to piksi 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
2013-10-16 Added pubs. Cleaned up non-power ERC errors. One last lookover. Added a couple testpads.
2013-12-03 Used the Piksi layout for RF portion off MAX2769.
2013-12-04 Big clean up on GPS board schematics.
2013-12-05 Fixed FIXMEs. Added TP on LD.
2013-12-14 Cleaned up part packages. Added exported partslist.
2013-12-14 Moved all parts onto the board in rough groupings.
2013-12-14 Laid the RF part. Four layers, AVDD and DVDD good where they meet.
2013-12-14 Testpoint breakouts matched to stm32. Other peripheral components grouped better.
2013-12-14 stm32f4 all connected to RF side of things.
2013-12-15 Need a go-ahead on the power section to continue, I think.
2013-12-15 Took a first try at Ethernet section. Tight but a little worried about trace widths.
2013-12-29 Ethernet basically done.
2013-12-29 Made ground pad half size to allow for vias under chip.
2013-12-29 Shrunk pad sizes to allow for vias in between the pads. Probably this is still OK for connections.
2013-12-29 Finished board layout. Removed some test pads. Needs review.
2014-01-06 BOM done. Board done. All parts reviewed. Ready for review & ship.
2014-01-06 Fixed BOM formatting so it's a pretty CSV file.
2014-01-20 Fixes as per design review. microUSB footprint needs help but symbol and signals OK. RF side placement adjusted but impedance 50 ohms wants 14mm wide trace. help.
2014-01-26 Updated microUSB symbol and library. Package not finalized.
2014-02-02 Major changes to to PWR and GPS sheets. No change to board layout yet, waiting on feedback.
2014-02-05 Made a capacitor options footprint and symbol for the 'do not populate' choice capacitor hack.
2014-02-05 New power parts added to layout and all power airwires resolved. Supply layer re-designed.
2014-02-05 Laid out new LNA1, LNA2, and ANTBIAS sections. Layout done. Passes ERC, DRC. Ready for design review.
2014-02-05 CLeaned up 2.85VA as an example layout; set tnames to the smallest usable size.
2014-02-08 ERC and DRC passed. Added ground vias everywhere. Fixed 0.1in breakout header by making new symbol, should be able to drop in a proper header if we want. Changed order of IO pins on sch to make sense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
2014-02-08 Exported all libraries.
2014-02-09 Fresh libraries export. Sent email to Andrew with notes.
2014-02-12 Fixed merge issues. Board opens OK.
2014-02-12 Cleanup on Jenner's fine work. Mostly adding polygons to power signals, some additional caps, moving parts around for optimal placement, added mounting holes, made polygon lines consistent. NOT DONE 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
2014-02-21 V2 BOM updated to match google doc.
2014-03-26 Beeeeg changes to GPS board. Caught many small mistakes in STM and LAN wiring and footprints, fixed. Better layout of magnetics, replumbed the lines between STM32 and LAN, and more. Passes ERC and DR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
2014-03-30 Switched to the KSZ8081RNA PHY layer IC, the best PHY layer IC ever. I'm sure we'll hate it later, but for now, it's great. New library and datasheet and schematic, still need to wire it up.
2014-03-30 PHY layout, plus connection to COTS GPS board via a 0.1" header that could also be (shock!) an FTDI cable. Last thing left: SAW filters!
2014-03-31 Checked SAW and LNA, moved to endfire SMA, still need to cleanup RF and also, see README for the beginning of a component writeup and a todo list.
2014-03-31 Better RF layout. Now doing tented vias for a tighter layout, also changed design rules to get same signal vias closer in to pads. Is 1x width enough clearance to ground for RF signals? And then the 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
2014-04-01 New, better, small, yellow, different crystal, and more notes on components.
2014-04-02 DONE.
2014-04-04 OMG TEST POINTS!!!!11!!
2014-04-04 Silly clean up, ran ERC and DRC again.
2014-06-12 Added modwire proposals for SPI 3-wire fix. See Issue 4 in gps-rf-board github repository.
2014-06-13 Removed SPI2_NSS modwire proposal from v2 schematic.
2014-06-13 Removed !SS line from patch, made it pretty, in schematic. Added older docs that should have been added. Updated BOM with digikey part numbers.
2014-06-13 Added annotation for DEBUG-PHY-MODWIRE (currently on prototype)
2014-06-15 Added notes on manufacturing and testing.
2014-06-28 Added modwire for SPI1-NSS. This should enable the use of STM32 SPI1 in slave mode to read data output.
2014-06-29 Cleaned up modwire patches a bit. Added cuts in 0.1" double header.
2014-06-29 Whoops, fixed CLK and DATA mixup from MAX using even MORE modwires.
2014-08-24 Moved values on top of pads for easy stuffing
2014-12-17 OMG, what did I just do? GPS 4 bit output to SPI converter, in EAGLE. Not sure if it works, but somebody should prototype this.
2014-12-17 OK, I had to polish it: names, test points, header inputs/outputs, no ERC errors.
2014-12-31 First cut at monolithic GPS board for AV4: MAX2769 + COTS GPS chip (SkyTraq 638). Still TONS to do, including the CPLD the stupid MAX2769 requires.
2015-01-28 First commit of the GPS v3 board, which includes the CPLD and SkyTraq ICs.
2015-01-28 More rough drafting on the CPLD. Added 1.8V supply (kind of), added some cleanup notes on clock, etc. TODO: everything still, including cleanup up 1.8V supply and probably splitting the power domains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
2015-02-01 using the GPS Carrier from AV4, expanded the size of the board to fit in the AV4 C channel and give more room. Moved everything onto that larger board, with preliminary placement. About to rip up and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
2015-02-18 New LNA+SAW filter, plus starting to lay stuff out.
2015-02-18 library part for high speed comparator
2015-03-01 Digital portion of v3 basically laid out, RF sections laid out. To do: verify CPLD power supply, think more about ground/power separation for RF section.
2015-03-02 Added link to the MAX2769 google doc, as well as renamed things to be BOM, and committed some minor changes in the layout and notes in the schematic.
2015-03-04 Added Test Board
    Added eagle file of GPS test board for Saw Filter and LNA chip
2015-03-18 90% done! All analog routed, only 9 airwires left to the CPLD which is trivial (but should be rerouted for easy of routing and also for maybe power domains? In any case, it just needs: stiching, doub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
2015-03-18 Shrunk board to 3.0 inches (OoooooooCD!), added the beginnings of stitched vias, cleanup here and there. TODO: final conections to CPLD, then cleanup.
2015-03-18 Couldn't help myself; wired all the things. Left to do: clean-up, mostly. Verify CPLD pins, verify MAX connections and SkyTraq connections, design review, etc.
2015-03-22 More tweaks, notes, board now almost done. Still to do: 42 MHz clock, double check power plane routing, 16MHz clock cleanup.
2015-03-25 Done! Removed power split plane because that was stupid on further reflection, added clock comparator, cleaned up ERCs and DRCs.
2015-03-25 Forgot to add a few ground vias....
2015-03-25 Forgot to add comparator library earlier. Added bzillions of test points, to CPLD and STM, for future mod wires :) Also left RF class isolate to 25 mils, forgot to reset that during the last commit. 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
2015-03-25 Added part numbers to some of the odder components. Found the supercap is no longer made, so switched it to an instock item. Also checked on other components, like the LNA and splitter. Cleaned up sc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
2015-03-28 So many little tweaks: updated ground planes, created BOM and then found out that everything doesn't exist anymore, so found new part numbers and in some cases (like the supercap) found new parts, ar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
2015-03-28 OK now it's really done. tnames cleaned up more, ERC and DRC gone over, BOM updated and price calculated, found lack of stock on certain items, etc.
2015-03-28 Updated the readme
2015-03-29 Added 1.8V library, cleaned up power layer after seeing gerbers, added more comments on schematic after viewing PDF, and commited both for those folks without EAGLE.
2015-04-01 Widended interface between digital and RF sections, added spacing to high speed MAX outputs, Added THads for scope ground clips and silk area for board #. Added GPS_RESET, and cleaned up STM scehamti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
2015-04-01 We broke oshpark! So we generated gerbers. Also, glad we did, because there were errors in the solder mask in some of the library parts, now fixed.
2015-04-29 Added Xilinx docs, and changed the SAW/LNA to the *correct* part number
2015-04-29 Added notes from bring up.
2015-04-29 separate out board versions
2015-04-29 The start of better documentation.
2015-05-07 Helper scripts for setting up the Venus COTS GPS
2015-05-18 Check the bit density of max2769 samples
2015-06-08 Updated all STM32 documentation
2015-06-08 updated MAX2769 datasheet, this time with the correct chip :(
2015-06-10 Updated Schematic and BOM with problems, wrong values, etc.
2015-06-24 Updated configuration script for Venus 8
2015-06-24 Found some more recent Venus 8 docs & bins
2015-06-29 Adding notes for the state of each board
2015-07-08 Added Venus 8 AN30
2015-07-13 Set up a working Venus 8 configuration.
    We haven't found a way to get raw measurement messages, but at least
    message A8 is coming through at the desired rate.
2015-12-02 pic to the readme!
2015-12-02 Links to data
2016-01-06 More updates on the SDG GPS project, cleaned up some docs.
2016-01-06 Uh, tables? Why not?
2016-01-06 Added block diagram pic
2016-01-06 Fixed Msps number.
2016-01-06 Fix table formatting in README
2018-07-17 Add files via upload
    Adding an initial board design for a GPS Front End to be used for OreSat SDR-GPS development. Currently, there is no dedicated GPS section in the OreSat repo, so this is a temporary location.
2018-07-17 Rename Summary.md to readme.mdwn
2018-08-02 Completed, reviewed usb_gps board design.
2018-08-02 Re-add the mounting holes.
2018-10-24 schematic cleanup
2019-02-23 Create cross_repo_test.md
    Testing GitHub Pages across repos.
2019-02-23 Create default.html
    Testing GitHub Pages across repos.
2019-03-20 Moved GPS-USB front end board over to Oresat repo.
