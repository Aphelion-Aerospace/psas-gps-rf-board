# Repository Aphelion-Aerospace/psas-gps-rf-board

File README:

Universal GPS RF Front-end Board

Current status: January 2014 - Ready to order v2 board and parts 

Author: Jenner Hanni <wicker>
School: Portland State University

License: BSD "3 clause" license.

BOM available at 
https://docs.google.com/spreadsheet/ccc?key=0Aj2ugLxWTS6bdDNQeDJjXzUxYTRNRFFiaVJvZ1Nmanc&usp=sharing

This is an RF front-end board that breaks out I and Q signals to serial, USB, and Ethernet for GPS receiver development. 

Several GPS receiver boards exist on the market to receive GPS satellite signals and process it to provide location data but these GPS receivers only give the final location. Getting access to the raw data before they go into correlators means you have to purchase a “RF front end” for hundreds of dollars, at which point you can work on projects like building an FPGA receiver board or developing a software radio receiver. 

Both of these projects are in-progress projects at Portland State, and are stalled on purchasing the very expensive RF front end. This project proposes to design, build, and release an open-source GPS receiver RF front-end board that would offer the GPS raw data over USB and serial outputs. Open source GPS receiver boards do exist, including in Andrew Greenberg’s GPL-GPS Master’s thesis, but all are based on very out dated and out-of-production GPS chipsets and are not easily acquired. 

Cost is also a factor: commercial RF front end boards are hundreds to thousands of dollars. And while the proposed chip for this project, the MAX2769 Universal GPS Receiver, costs only $5, the development kit is $600 -- in other words, cost prohibitive for a small project and frustrating for embedded software developers who may not have the time or experience to design and build their own hardware.

## EAGLE design v3-gps.brd

Notes on the sheet:
STM32F407
RMII
KSZ8081 Ethernet PHY IC
RocketNet Connector
SDIO (4 bit)
uSD card
SkyTraq Venus638 GPS
Xylinx CoolRunner2 CPLD
115k UART
42 Mbps SPI
MAX2769 GPS Front End
2 bit I+Q (4 Msps)
GHz Splitter
SAW + LNA
SMA
10 - 20 V system power
LMZ12001TZ 3.3V SPS
1.8V core and 2.85V low noise analog supplies
From passive -8 dBi cylindrical linear patch antenna
"RocketNet" Power + Ethernet (not PoE!) distribution bus
Block Diagram

Parts:
C21, C54, C55, C70, C77, C78: 100n; .0402-C-NOSILK
C25: 100n 50V; .0402-C-NOSILK
C26: 22n; .0402-C-NOSILK
C33: 10u 50V; 1206-C
C38: 100u; EIA6032
C39, C40, C41, C42, C59, C67, C68, C75: 1u; .0603-B-NOSILK
C43, C60, C69: 10n; .0402-C-NOSILK
C65: 1u 50V; .0603-B-NOSILK
C76: 2.2u; .0603-B-NOSILK
D2: DIODE-0603; 0603-B-NOSILK-DIODE
LED1: GREEN; CHIPLED_0603
R1: 3.32k; 0402-C-NOSILK@1
R3: 1.07k; 0402-C-NOSILK@1
R6: 1k; 0402-C-NOSILK@1
R7: 61.9k; 0402-C-NOSILK@1
TP3, TP6, TP7, TP9, TP11, TP12, TP13, TP14, TP15, TP17, TP18, TP19, TP20, TP21: TEST-POINT15MIL-TEST-POINT; 15MIL-TEST-POINT
U6, U7, U11: MAX8510EXK29+T; SC70
U8: LMZ12001TZ-ADJ/NOPB; TO-PMOD-7
U14: MIC5319-1.8V; SOT-23-5
U$1, U$12, U$14, U$18: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER

Connections:
1.8V: C76.1, C77.1, C78.1, TP21.P$1, U14.5 (OUT); also elsewhere on the board
2.85V-S: C68.1, C69.1, C70.1, TP9.P$1, U11.5 (OUT); also elsewhere on the board
2.85VA: C42.1, C43.1, C55.1, TP15.P$1, U7.5 (OUT); also elsewhere on the board
2.85VD: C59.1, C60.1, TP14.P$1, U6.5 (OUT); also elsewhere on the board
3.3VD: C26.1, C38.P$1 (+), C39.1, C40.1, C41.1, C54.1, C67.1, C75.1, LED1.A, R1.2, TP13.P$1, U6.1 (IN), U6.3 (EN), U7.1 (IN), U7.3 (EN), U8.7 (VOUT), U11.1 (IN), U11.3 (EN), U14.1 (IN), U14.3 (EN); also elsewhere on the board
GND: C21.2, C25.2, C33.2, C38.P$2 (-), C39.2, C40.2, C41.2, C42.2, C54.2, C55.2, C59.2, C65.2, C67.2, C68.2, C70.2, C75.2, C76.2, C78.2, R3.1, R6.1, TP3.P$1, TP6.P$1, TP7.P$1, TP17.P$1, TP18.P$1, TP19.P$1, TP20.P$1, U6.2 (GND), U7.2 (GND), U8.4 (GND), U8.EP, U11.2 (GND), U14.2 (GND); also elsewhere on the board
unnamed: TP11.P$1, U8.3 (EN)
unnamed: C69.2, U11.4 (BP)
unnamed: C21.1, U8.5 (SS)
unnamed: C26.2, R1.1, R3.2, U8.6 (FB)
unnamed: R7.2, U8.2 (RON)
unnamed: C43.2, U7.4 (BP)
unnamed: C60.2, U6.4 (BP)
unnamed: LED1.C, R6.2
unnamed: C77.2, U14.4 (BYP)
USB_FS_VBUS: D2.ANODE; also elsewhere on the board
VIN: C25.1, C33.1, C65.1, D2.CATHODE, R7.1, TP12.P$1, U8.1 (VIN); also elsewhere on the board

Notes on the sheet:
4.5V (Vusb) to 20V (Shore power) Power in from RocketNet Connector
2.85V digital supply for MAX2769
Power from USB port for debugging
2.85V For SkyTraq supply
1.8V internal supply For CPLD
2.85V analog supply for MAX2769
Low noise LDO supplies for RF ICs
Fsw = 410 kHz
Power Supplies

Parts:
C1: 330p; .0402-C-NOSILK
C56: 100n; .0402-C-NOSILK
C81: 47p; .0402-C-NOSILK
J2: CON_SMA-ENDFIRE_EMERSON_EMERSON-142-0701-801; SMA-CON-EMERSON
L2: 22n; .0402-B-NOSILK
L5: 1.8n; .0402-B-NOSILK
R13: 10; 0402-C-NOSILK@1
R25: 4.7k; 0402-C-NOSILK@1
SH1: BMI-S-202-SHIELD; BMI-S-202
U10: BP2G+; MINICIRCUITS
U12: ALM-GP003; AVAGO+SAW+LNA

Connections:
2.85VA: C1.1, L2.2, R13.1, R25.1; also elsewhere on the board
AGND: C1.2, C56.2, C81.2, J2.GND, J2.GND@1 (GND), J2.GND@2 (GND), J2.GND@3 (GND), SH1.P$1, SH1.P$2, SH1.P$3, SH1.P$4, SH1.P$5, SH1.P$6, SH1.P$7, SH1.P$8, SH1.P$9, SH1.P$10, SH1.P$11, SH1.P$12, U10.1 (GND), U10.3 (GND), U10.4 (GND), U10.6 (GND), U10.7 (GND), U12.2 (GND), U12.3 (GND), U12.4 (GND), U12.9 (GND), U12.P$1 (GND), U12.P$2 (GND); also elsewhere on the board
LNA-POWER-FILTERED: C56.1, C81.1, L2.1, L5.1, R13.2
MAX-RF: U10.8 (PORT1); also elsewhere on the board
unnamed: J2.SIG, U12.1 (RF-IN)
unnamed: U10.2 (SUM), U12.6 (RF-OUT)
unnamed: R25.2, U12.8 (SD)
unnamed: L5.2, U12.7 (VDD)
STQ-RF: U10.5 (PORT2); also elsewhere on the board

Notes on the sheet:
SMA Connector
Soldered down RF shield with cap
Mini-Circuits L band Splitter
GPS LNA +19 dB, NF = 1.66 dB
SMA and coax to to L1 band linearly polarized "wrap around" cylindrical patch antennas on rocket aeroshell (-8 dBi typical).
RF front end

Parts:
C2: 10n; .0402-C-NOSILK
C3: 27p; .0402-C-NOSILK
C4: 470p; .0402-C-NOSILK
C5, C7, C9, C13, C15, C18, C31, C64, C71, C72, C73, C74, C83, C84: 100n; .0402-C-NOSILK
C6, C8, C12, C14, C16, C17, C57, C63: 100p; .0402-C-NOSILK
C53, C58: 2.2u; .0603-B-NOSILK
JP1: PINHD-1X6; 1X06
L8: SF14-1575F5UU19; SAW_1.4X1.1
R2: 20k; 0402-C-NOSILK@1
R4: 1k; 0402-C-NOSILK@1
R5, R8, R9, R26, R27: 10k; 0402-C-NOSILK@1
TP1, TP10, TP23, TP24, TP31, TP34: TEST-POINT15MIL-TEST-POINT; 15MIL-TEST-POINT
U1: MAX2769ETI+; 90-0023
U4: 7Q-16.368MBG-T; TCX_7Q
U5: LT1719S6; SOT23-6
U13: XC2C64A-5VQG44C; VQ44

Connections:
1.8V: C74.1, U13.15 (VDDINT); also elsewhere on the board
2.85VA: C5.1, C6.1, C8.1, C12.1, C13.1, C15.1, C16.1, C18.1, C58.1, U1.4 (VCCRF), U1.11 (VCCVCO), U1.13 (VCCCP), U1.23 (VCCIF); also elsewhere on the board
2.85VD: C7.1, C9.1, C14.1, C17.1, C31.1, C53.1, C57.1, R5.2, U1.14 (VCCD), U1.19 (VCCADC), U4.4 (VDD); also elsewhere on the board
3.3VD: C71.1, C72.1, C73.1, C83.1, JP1.1, U5.4 (V+), U13.7 (VDDIO1), U13.26 (VDDIO2), U13.35 (VDDAUX); also elsewhere on the board
AGND: C3.2, C4.2, C5.2, C6.2, C8.2, C12.2, C13.2, C15.2, C16.2, C18.2, C31.2, C53.2, C57.2, C58.2, C63.2, C64.2, L8.2 (GND), L8.3 (GND), L8.5 (GND), U1.BODY, U4.1 (GND1), U4.2 (GND2); also elsewhere on the board
ANTBIAS: C63.1, C64.1, TP10.P$1, U1.3 (ANTBIAS)
CPLD_DEBUG: U13.19 (IO_15); also elsewhere on the board
CPLD_IN_ONLY: R26.2, U13.18 (IN_32)
CPLD_OUT_SPI1_MOSI: U13.20 (IO_14); also elsewhere on the board
CPLD_OUT_SPI1_NSS: U13.21 (IO_13); also elsewhere on the board
CPLD_OUT_SPI1_SCK: U13.23 (IO_11); also elsewhere on the board
CPLD_OUT_SPI_CLK_SRC: U13.22 (IO_12); also elsewhere on the board
CPLD_RESET: U13.14 (IO_30); also elsewhere on the board
CPOUT: C3.1, R2.1, U1.12 (CPOUT)
GND: C7.2, C9.2, C14.2, C17.2, C71.2, C72.2, C73.2, C74.2, C83.2, C84.2, JP1.2, R4.2, R8.1, R9.1, R26.1, U5.2 (V-), U5.6 (SD), U13.4 (GND), U13.17 (GND), U13.25 (GND); also elsewhere on the board
I0: U1.20 (I0), U13.29 (IO_8)
I1: U1.21 (I1), U13.28 (IO_9)
LNAOUT: L8.1 (IN), U1.2 (LNAOUT)
MAX-CLKOUT: U5.5 (OUT), U13.32 (IO_5)
MAX-RF: U1.25 (LNA2); also elsewhere on the board
MAX_!IDLE: R9.2, U1.24 (!IDLE); also elsewhere on the board
MAX_!SHDN: R8.2, U1.7 (!SHDN); also elsewhere on the board
MAX_ANTFLAG: U1.1 (ANTFLAG); also elsewhere on the board
MAX_CFG_!CS: R5.1, U1.10 (!CS); also elsewhere on the board
MAX_CFG_SPI2_MOSI: U1.8 (SDATA); also elsewhere on the board
MAX_CFG_SPI2_SCLK: U1.9 (SCLK); also elsewhere on the board
MAX_CLK_OUT: R27.2, U1.16 (CLKOUT), U5.3 (+IN)
MAX_LD: U1.6 (LD); also elsewhere on the board
MIXIN: L8.4 (OUT), U1.5 (MIXIN)
unnamed: JP1.6, U13.10 (TMS)
unnamed: TP24.P$1, U13.44 (IO_21)
unnamed: TP23.P$1, U13.42 (IO_19)
unnamed: TP31.P$1, U13.40 (IO_17)
unnamed: JP1.5, U13.9 (TDI)
unnamed: C4.1, R2.2
unnamed: C84.1, R27.1, U5.1 (-IN)
unnamed: TP34.P$1, U13.38 (IO_0)
unnamed: JP1.4, U13.24 (TDO)
unnamed: C2.1, U4.3 (OUT)
unnamed: JP1.3, U13.11 (TCK)
PGM: R4.1, U1.26 (PGM)
Q0: U1.18 (Q0), U13.30 (IO_7)
Q1: U1.17 (Q1), U13.31 (IO_6)
XTAL: C2.2, TP1.P$1, U1.15 (XTAL)

Notes on the sheet:
Digital Supplies
Analog Supplies
MAX2769 SPI CONFIG port
4 bits I/Q data @ 4.092 Msps
42 Mbps SPI to STM32
SPI reference clock from STM32
JTAG Programming header
16.368 MHz TCXO
0.8V clipped sign
MAX2769 + CPLD interface

Parts:
C19, C79: 1u; .0603-C-NOSILK
C22, C80: 100p; .0402-C-NOSILK
C24, C82: 100n; .0402-C-NOSILK
C85: DSK-3R3H334T-HL; CAP-ELNA-DS-SERIES
D1: DIODE-0603; 0603-B-NOSILK-DIODE
LED7: YLW; CHIPLED_0603
R21: 33k; 0402-C-NOSILK@1
R22: 10k; 0402-C-NOSILK@1
R23, R24: 1k; 0402-C-NOSILK@1
TP8, TP25, TP27, TP28, TP29, TP30: TEST-POINT15MIL-TEST-POINT; 15MIL-TEST-POINT
U9: VENUS838FLPX-L; VENUS638FLPX

Connections:
2.85V-S: C19.1, C22.1, C79.1, C80.1, D1.ANODE, LED7.A, R21.2, U9.2 (VCC), U9.36 (REGEN), U9.58 (VCC); also elsewhere on the board
AGND: U9.21 (GNDRF), U9.22 (GNDRF), U9.24 (GNDRF), U9.25 (GNDRF), U9.27 (GNDRF), U9.28 (GNDRF), U9.29 (GNDRF), U9.31 (GNDRF), U9.33 (GNDRF), U9.61 (GNDRF), U9.62 (GNDRF), U9.65 (GNDRF), U9.69 (GNDRF); also elsewhere on the board
GND: C19.2, C22.2, C24.1, C79.2, C80.2, C82.1, C85.-, R22.1, U9.10 (GND), U9.11 (GND), U9.15 (GND), U9.19 (GND), U9.49 (GND), U9.60 (GND), U9.64 (GND); also elsewhere on the board
LED/GPIO: R23.2, TP29.P$1, U9.7 (LED/GPIO0)
unnamed: R22.2, U9.9 (BTSEL)
unnamed: LED7.C, R23.1
unnamed: D1.CATHODE, R24.2
RTC: TP8.P$1, U9.17 (RTC)
STM_USART6_RX: TP27.P$1, U9.44 (TXD0); also elsewhere on the board
STM_USART6_TX: TP25.P$1, U9.42 (RXD0); also elsewhere on the board
STQ-!RST: C24.2, R21.1, TP28.P$1, U9.1 (RSTN)
STQ-PPS: TP30.P$1, U9.40 (PPS)
STQ-RF: U9.32 (RFIN); also elsewhere on the board
STQ-VBAT: C82.2, C85.+, R24.1, U9.18 (VBAT)

Notes on the sheet:
1.2V LDO out
SuperCap!
2.85V-S is the skytraq specific power supply. Meant to decouple from other analog and main digital supplies
SkyTraq VENUS638 GPS
NMEA / Binary UART to STM32

Parts:
C10, C11, C45, C46, C47, C48, C49, C50, C61: 100n; .0402-C-NOSILK
C20, C51, C52: 2.2u; .0603-B-NOSILK
C29, C30: 10p; .0402-C-NOSILK
C62: 1n 2kv; .0402-C-NOSILK
J1: 1.27MM-SWD-CONNECTOR; 1.27MM_2X5
J4: ZX62D-B-5P8
J7: CON_HIROSE_DM3D(MICROSD); HIROSE_DM3D(MICRO-SD)
LED2, LED4, LED5: YLW; CHIPLED_0603
LED3: SMLV56RGB1W1; LED-3528
Q1: NTR4101P; SOT23
R12, R18, R19: 10k; 0402-C-NOSILK@1
R14, R16, R20, R38, R39, R40: 3.32k; 0402-C-NOSILK@1
TP2, TP4, TP5: TPTP06R; TP06R
TP35, TP36, TP38, TP39, TP40: TEST-POINT15MIL-TEST-POINT; 15MIL-TEST-POINT
U2: STM32F407VG; LQFP100
X1: 25 MHz; 8Y

Connections:
3.3VD: C11.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C61.2, J1.VTREF, LED3.1 (A), LED3.2 (A), LED3.3 (A), Q1.2 (S), R12.2, R14.2, R16.2, R18.2, R20.2, TP4.TP, TP5.TP, U2.6 (VBAT), U2.11 (VDD), U2.19 (VDD), U2.21 (VREF+), U2.22 (VDDA), U2.28 (VDD), U2.50 (VDD), U2.75 (VDD), U2.100 (VDD); also elsewhere on the board
!RST: J1.!RESET, R18.1, U2.14 (NRST)
BOOT0: R19.1, U2.94 (BOOT0)
CPLD_DEBUG: U2.59 (PD12); also elsewhere on the board
CPLD_OUT_SPI1_MOSI: U2.91 (PB5); also elsewhere on the board
CPLD_OUT_SPI1_NSS: U2.29 (PA4); also elsewhere on the board
CPLD_OUT_SPI1_SCK: U2.30 (PA5); also elsewhere on the board
CPLD_OUT_SPI_CLK_SRC: U2.53 (PB14); also elsewhere on the board
CPLD_RESET: U2.69 (PA10); also elsewhere on the board
ETH_CRS_DV: U2.32 (PA7); also elsewhere on the board
ETH_DEBUG: U2.1 (PE2); also elsewhere on the board
ETH_MCO1_CLK: U2.67 (PA8); also elsewhere on the board
ETH_MDC: U2.16 (PC1); also elsewhere on the board
ETH_MDINT: U2.26 (PA3); also elsewhere on the board
ETH_MDIO: U2.25 (PA2); also elsewhere on the board
ETH_PHY_NRST: U2.84 (PD3); also elsewhere on the board
ETH_RMII_REF_CLK: U2.24 (PA1); also elsewhere on the board
ETH_RXD0: U2.33 (PC4); also elsewhere on the board
ETH_RXD1: U2.34 (PC5); also elsewhere on the board
ETH_TXD0: U2.51 (PB12); also elsewhere on the board
ETH_TXD1: U2.52 (PB13); also elsewhere on the board
ETH_TX_EN: U2.48 (PB11); also elsewhere on the board
GND: C10.1, C11.1, C20.1, C29.1, C30.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C61.1, C62.1, J1.GND, J1.GND@2 (GND), J1.GNDDET, J4.P5 (GND), J7.G1 (PAD), J7.G2 (PAD), J7.G3 (PAD), J7.G4 (PAD), J7.P6 (6), J7.S0 (0), R19.2, U2.10 (VSS), U2.20 (VSSA), U2.27 (VSS), U2.74 (VSS), U2.99 (VSS), X1.2 (3), X1.4 (3); also elsewhere on the board
LED2: LED2.C, U2.55 (PD8)
LED4: LED4.C, U2.56 (PD9)
LED5: LED5.C, U2.57 (PD10)
MAX_!IDLE: U2.42 (PE11); also elsewhere on the board
MAX_!SHDN: U2.41 (PE10); also elsewhere on the board
MAX_ANTFLAG: U2.36 (PB1); also elsewhere on the board
MAX_CFG_!CS: U2.43 (PE12); also elsewhere on the board
MAX_CFG_SPI2_MOSI: U2.54 (PB15); also elsewhere on the board
MAX_CFG_SPI2_SCLK: U2.47 (PB10); also elsewhere on the board
MAX_LD: U2.37 (PB2); also elsewhere on the board
unnamed: LED3.5 (K), R38.1
unnamed: LED3.4 (K), R39.1
unnamed: LED3.6 (K), R40.1
unnamed: J7.S1 (1), TP2.TP
unnamed: LED2.A, R14.1
unnamed: TP35.P$1, U2.86 (PD5)
unnamed: LED4.A, R16.1
unnamed: LED5.A, R20.1
unnamed: TP36.P$1, U2.88 (PD7)
unnamed: TP38.P$1, U2.35 (PB0)
unnamed: TP39.P$1, U2.2 (PE3)
unnamed: TP40.P$1, U2.4 (PE5)
OSC_IN: C30.2, U2.12 (PH0), X1.1
OSC_OUT: C29.2, U2.13 (PH1), X1.3 (2)
RGB-B: R40.2, U2.58 (PD11)
RGB-G: R39.2, U2.61 (PD14)
RGB-R: R38.2, U2.60 (PD13)
SD-VDD: C10.2, C20.2, J7.P4 (4), Q1.3 (D)
SDIO_CLK: J7.P5 (5), U2.80 (PC12)
SDIO_CMD: J7.P3 (3), U2.83 (PD2)
SDIO_D0: J7.P7 (7), U2.65 (PC8)
SDIO_D1: J7.P8 (8), U2.66 (PC9)
SDIO_D2: J7.P1 (1), U2.78 (PC10)
SDIO_D3: J7.P2 (2), U2.79 (PC11)
SDIO_PWR: Q1.1 (G), R12.1, U2.81 (PD0)
SHLD: C62.2, J4.P$1 (SHLD), J4.P$2 (SHLD), J4.P$3 (SHLD), J4.P$4 (SHLD)
STM_USART6_RX: U2.64 (PC7); also elsewhere on the board
STM_USART6_TX: U2.63 (PC6); also elsewhere on the board
TCK: J1.SWDCLK (SWDCLK/TCK), U2.76 (PA14)
TDI: J1.NC (NC/TDI), U2.77 (PA15)
TDO: J1.SWO (SWO/TDO), U2.89 (PB3)
TMS: J1.SWDIO (SWDIO/TMS), U2.72 (PA13)
USB_FS_DM: J4.P2 (D-), U2.70 (PA11)
USB_FS_DP: J4.P3 (D+), U2.71 (PA12)
USB_FS_VBUS: J4.P1 (VCC), U2.68 (PA9); also elsewhere on the board
VCAP_1: C52.2, U2.49 (VCAP_1)
VCAP_2: C51.2, U2.73 (VCAP_2)

Notes on the sheet:
MICROSD
PB15: SPI2_MOSI / AF=5
USB 2.0 Full Speed
MicroSD Card
SWD Programmer
TO MAX2769
TO SKYTRAQ GPS
(MCO1)
(BOOT1)
(MCO2)
Microcontroller

Notices in the files:
parts and their libraries:
SparkFun-Passives: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-RF: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
