# Repository Aphelion-Aerospace/psas-gps-rf-board

File README:

Universal GPS RF Front-end Board

Current status: January 2014 - Ready to order v2 board and parts 

Author: Jenner Hanni <wicker>
School: Portland State University

License: BSD "3 clause" license.

BOM available at 
https://docs.google.com/spreadsheet/ccc?key=0Aj2ugLxWTS6bdDNQeDJjXzUxYTRNRFFiaVJvZ1Nmanc&usp=sharing

This is an RF front-end board that breaks out I and Q signals to serial, USB, and Ethernet for GPS receiver development. 

Several GPS receiver boards exist on the market to receive GPS satellite signals and process it to provide location data but these GPS receivers only give the final location. Getting access to the raw data before they go into correlators means you have to purchase a “RF front end” for hundreds of dollars, at which point you can work on projects like building an FPGA receiver board or developing a software radio receiver. 

Both of these projects are in-progress projects at Portland State, and are stalled on purchasing the very expensive RF front end. This project proposes to design, build, and release an open-source GPS receiver RF front-end board that would offer the GPS raw data over USB and serial outputs. Open source GPS receiver boards do exist, including in Andrew Greenberg’s GPL-GPS Master’s thesis, but all are based on very out dated and out-of-production GPS chipsets and are not easily acquired. 

Cost is also a factor: commercial RF front end boards are hundreds to thousands of dollars. And while the proposed chip for this project, the MAX2769 Universal GPS Receiver, costs only $5, the development kit is $600 -- in other words, cost prohibitive for a small project and frustrating for embedded software developers who may not have the time or experience to design and build their own hardware.

## KiCad design GPS-USB_Front_End_Board/kicad_board_design/usb_gps.kicad_pcb

Board: 4 copper layers, 99.1 x 53.3 mm, 84 parts (0 on the bottom side), 67 nets.

Parts:
C1, C18: 1uF; C_0603_HandSoldering
C2, C6, C8, C11, C13, C14, C15, C16, C21, C22, C23, C30: .1uF; C_0402
C3, C5: 10pF; C_0805_HandSoldering
C4, C34: 3.3uF; C_0805_HandSoldering
C7: 2.2uF; C_0805_HandSoldering
C9, C10, C29: NC; C_0805_HandSoldering
C12: 33pF; C_0603_HandSoldering
C17, C31, C32: 100pF; C_0805_HandSoldering
C19: .1nF; C_0805_HandSoldering
C20: 3300pF; C_0603_HandSoldering
C24: 10uF; C_0805_HandSoldering
C25: 27pF; C_0805_HandSoldering
C26: 10nF; C_0402
C27: 470pF; C_0402
C28: .47nF; C_0402
C33, C35: 100 nF; C_0402
D1: USBLC6-2SC6; SOT23-6L
F1: Polyfuse_Small; 0805L_Littelfuse
FB1, FB2: BLM18PG471SN1D; 0603
J1: 10118192-0001LF; USB_Micro_B_Female_10118192
J2, J3: Edge Launch SMA; RF_SMA_Receptical_Vertical_CONSMA001-SMD-G
L1: NC; Choke_SMD_1206_Handsoldering
L2: 6.2nH; C_0603_HandSoldering
L3: 4.3nH; C_0402
L4: 33nH; C_0402
P1: CONN_02X12; Pin_Header_Straight_2x12
R1, R3, R4, R5, R7: 10K; R_0805_HandSoldering
R2: 12.0K; R_0603_HandSoldering
R6: 2K; R_0603_HandSoldering
R8, R9, R10, R12, R14, R15, R16, R17, R18: 0; R_0805_HandSoldering
R11: NC; R_0805_HandSoldering
R13: 20K; R_0603_HandSoldering
REF1, REF2, REF3, REF4: MountingHole_2.5mm
TP1, TP2, TP3, TP4, TP5, TP6: TEST; Test_Point
U1: 93LCxxB; SOIC127P600X175-8N
U2: FT2232HL-REEL; LQFP-64_10x10mm
U3: L4931ABD33-TR; SOIC-8_W3.9mm
U4, U7: SAWTEK-855969; Sawtek_855969
U5: AP131-30; SOT-23-5
U6: MAX2769CETI+; TQFP_29_EP_MAX2769
X1: TCXO3; CTS_405_xtal
Y1: Crystal_GND24; CTS_405_xtal

Connections:
/MAX_2769/+5V: C6.1, C18.1, FB1.1, P1.2, P1.4, TP3.1, U3.5, U3.8, U5.1, U5.3
/MAX_2769/ANTBIAS: C30.1, C31.1, L4.1, U6.3
/MAX_2769/ANTFLAG: U2.26, U6.1
/MAX_2769/CLKOUT: C26.2, R14.2
/MAX_2769/CS#: R10.1, U6.10
/MAX_2769/D0: P1.6, R18.1
/MAX_2769/D1: P1.8, R17.1
/MAX_2769/D2: P1.10, R16.1
/MAX_2769/D3: P1.12, R15.1
/MAX_2769/I0: R17.2, U6.20
/MAX_2769/I1: R18.2, U6.21
/MAX_2769/LNA1: L3.2, U6.27
/MAX_2769/LNA2: C32.2, U6.25
/MAX_2769/MIXIN: C29.2, U6.5, U7.5
/MAX_2769/Q0: R16.2, U6.18
/MAX_2769/Q1: R15.2, U6.17
/MAX_2769/SCLK: P1.18, R8.2
/MAX_2769/SCLKL: R8.1, U6.9
/MAX_2769/SCS: P1.24, R10.2
/MAX_2769/SDATA: R9.1, U6.8
/MAX_2769/SDO: P1.22, R9.2
/MAX_2769/VCC3V: C10.1, C11.1, C13.1, C14.1, C15.1, C16.1, C19.1, C21.1, C22.1, C24.1, L1.1, R7.2, R11.2, U5.5, U6.4, U6.11, U6.13, U6.14, U6.19, U6.23, X1.4
/MAX_2769/WR#: P1.16, R14.1
/USB_FT2232/D0: P1.7, U2.38
/USB_FT2232/D1: P1.5, U2.39
/USB_FT2232/D2: P1.9, U2.40
/USB_FT2232/D3: P1.11, U2.41
/USB_FT2232/Data+: D1.6, U2.8
/USB_FT2232/Data-: D1.4, U2.7
/USB_FT2232/EECLK: R3.2, U1.2, U2.62
/USB_FT2232/EECS: R1.2, U1.1, U2.63
/USB_FT2232/GPIO1: U2.27, U6.6
/USB_FT2232/GPIO2: R7.1, U2.28, U6.7
/USB_FT2232/GPIO3: U2.29, U6.24
/USB_FT2232/OSCO: C5.1, TP6.1, U2.3, Y1.3
/USB_FT2232/REF: R2.1, U2.6
/USB_FT2232/RESET: R4.2, TP2.1, U2.14
/USB_FT2232/SCLK: P1.17, U2.16
/USB_FT2232/SCS: P1.23, U2.19
/USB_FT2232/SDI: P1.19, U2.18
/USB_FT2232/SDO: P1.21, U2.17
/USB_FT2232/TXE#: P1.13, U2.52
/USB_FT2232/VBUS: C8.1, D1.5, F1.2, J1.1, TP4.1
/USB_FT2232/VCC3V3: C1.1, C2.1, C7.1, C34.1, C35.1, FB2.1, R1.1, R3.1, R4.1, R5.1, TP5.1, U1.8, U2.4, U2.9, U2.20, U2.31, U2.42, U2.50, U2.56
/USB_FT2232/VREGOUT: C4.1, C33.1, U2.12, U2.37, U2.49, U2.64
/USB_FT2232/WR#: P1.15, U2.54
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C27.2, C30.2, C31.2, C33.2, C34.2, C35.2, D1.2, J1.5, J2.1, J3.1, L2.2, P1.1, P1.3, R2.2, R12.1, TP1.1, U1.5, U2.1, U2.5, U2.10, U2.11, U2.13, U2.15, U2.25, U2.35, U2.47, U2.51, U3.2, U3.3, U3.6, U3.7, U4.1, U4.3, U4.4, U4.6, U5.2, U6.29, U7.1, U7.3, U7.4, U7.6, X1.2, Y1.2, Y1.4
unnamed: C3.1, U2.2, Y1.1
unnamed: C9.1, C12.1, J2.2, L1.2
unnamed: C12.2, C17.1, L2.1, U4.2
unnamed: C17.2, L3.1, U4.5
unnamed: C20.1, X1.3
unnamed: C20.2, U6.15
unnamed: C23.1, U5.4
unnamed: C25.1, R13.2, U6.12
unnamed: C26.1, U6.16
unnamed: C27.1, R13.1
unnamed: C28.1, U6.2
unnamed: C28.2, C29.1, U7.2
unnamed: C32.1, J3.2, L4.2
unnamed: D1.1, J1.3
unnamed: D1.3, J1.2
unnamed: F1.1, FB1.2
unnamed: FB2.2, U3.1
unnamed: R5.2, R6.2, U1.4
unnamed: R6.1, U1.3, U2.61
unnamed: R11.1, R12.2, U6.26

## Commit log

2013-04-16 Rewrote.
2013-04-17 Added STM32F407 144-pin footprint.
2013-04-17 Swapped for 144-pin STM32F4 and started schema changes.
2013-05-08 Added parts list for v1.
2013-07-21 Adding references.
2013-07-21 Remove file.
2013-09-22 Using 100-pin STM32F4 package. Moved existing peripherals over.
2013-09-28 Changed JTAG connector to standard 2x5 mini. Broke out GPIO and SPI lines to GPS chip. Added some testpoints. Added STM32F4 reset lines and hooked to JTAG.
2013-09-28 Added LEDs.
2013-09-28 Reconciled all ERC errors except for power/ground mismatches.
2013-09-29 Added testpoints. Verified pull-up and pull-down lines between STM32F4 and GPS chip. Verified Ethernet PHY circuit. Need Rocketnet connector info. ERC only complains about power/supply mismatch.
2013-09-29 Started replacing RJ-rt with 16-pin Rocketnet connector.
2013-10-04 Cosmetic changes. Waiting on design review with Andrew. Ethernet not entirely done.
2013-10-05 Reviewed with Andrew. Changed 2.2uF packages to 0603. Removed bootloader pins on stm32f4. Added some names. Removed R values on JTAG T lines as per working rocketnet hub circuit. Made USB power pin N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
2013-10-05 Found application circuit that does what we want and is OK for 4.5V-26V. Added backfeed protection from USB 5V input and connected to Rocketnet input. Added the linear regulator and LT4619 buck dc/dc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
2013-10-06 Added LEDs to linear regulator for 5V and 3.3VA. Made another pass over Ethernet. The only weird place left is in the PHY_CLK_25MHz and REF_CLK signals. Also need to compare gps chip analog to piksi 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
2013-10-16 Added pubs. Cleaned up non-power ERC errors. One last lookover. Added a couple testpads.
2013-12-03 Used the Piksi layout for RF portion off MAX2769.
2013-12-04 Big clean up on GPS board schematics.
2013-12-05 Fixed FIXMEs. Added TP on LD.
2013-12-14 Cleaned up part packages. Added exported partslist.
2013-12-14 Moved all parts onto the board in rough groupings.
2013-12-14 Laid the RF part. Four layers, AVDD and DVDD good where they meet.
2013-12-14 Testpoint breakouts matched to stm32. Other peripheral components grouped better.
2013-12-14 stm32f4 all connected to RF side of things.
2013-12-15 Need a go-ahead on the power section to continue, I think.
2013-12-15 Took a first try at Ethernet section. Tight but a little worried about trace widths.
2013-12-29 Ethernet basically done.
2013-12-29 Made ground pad half size to allow for vias under chip.
2013-12-29 Shrunk pad sizes to allow for vias in between the pads. Probably this is still OK for connections.
2013-12-29 Finished board layout. Removed some test pads. Needs review.
2014-01-06 BOM done. Board done. All parts reviewed. Ready for review & ship.
2014-01-06 Fixed BOM formatting so it's a pretty CSV file.
2014-01-20 Fixes as per design review. microUSB footprint needs help but symbol and signals OK. RF side placement adjusted but impedance 50 ohms wants 14mm wide trace. help.
2014-01-26 Updated microUSB symbol and library. Package not finalized.
2014-02-02 Major changes to to PWR and GPS sheets. No change to board layout yet, waiting on feedback.
2014-02-05 Made a capacitor options footprint and symbol for the 'do not populate' choice capacitor hack.
2014-02-05 New power parts added to layout and all power airwires resolved. Supply layer re-designed.
2014-02-05 Laid out new LNA1, LNA2, and ANTBIAS sections. Layout done. Passes ERC, DRC. Ready for design review.
2014-02-05 CLeaned up 2.85VA as an example layout; set tnames to the smallest usable size.
2014-02-08 ERC and DRC passed. Added ground vias everywhere. Fixed 0.1in breakout header by making new symbol, should be able to drop in a proper header if we want. Changed order of IO pins on sch to make sense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
2014-02-08 Exported all libraries.
2014-02-09 Fresh libraries export. Sent email to Andrew with notes.
2014-02-12 Fixed merge issues. Board opens OK.
2014-02-12 Cleanup on Jenner's fine work. Mostly adding polygons to power signals, some additional caps, moving parts around for optimal placement, added mounting holes, made polygon lines consistent. NOT DONE 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
2014-02-21 V2 BOM updated to match google doc.
2014-03-26 Beeeeg changes to GPS board. Caught many small mistakes in STM and LAN wiring and footprints, fixed. Better layout of magnetics, replumbed the lines between STM32 and LAN, and more. Passes ERC and DR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
2014-03-30 Switched to the KSZ8081RNA PHY layer IC, the best PHY layer IC ever. I'm sure we'll hate it later, but for now, it's great. New library and datasheet and schematic, still need to wire it up.
2014-03-30 PHY layout, plus connection to COTS GPS board via a 0.1" header that could also be (shock!) an FTDI cable. Last thing left: SAW filters!
2014-03-31 Checked SAW and LNA, moved to endfire SMA, still need to cleanup RF and also, see README for the beginning of a component writeup and a todo list.
2014-03-31 Better RF layout. Now doing tented vias for a tighter layout, also changed design rules to get same signal vias closer in to pads. Is 1x width enough clearance to ground for RF signals? And then the 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
2014-04-01 New, better, small, yellow, different crystal, and more notes on components.
2014-04-02 DONE.
2014-04-04 OMG TEST POINTS!!!!11!!
2014-04-04 Silly clean up, ran ERC and DRC again.
2014-06-12 Added modwire proposals for SPI 3-wire fix. See Issue 4 in gps-rf-board github repository.
2014-06-13 Removed SPI2_NSS modwire proposal from v2 schematic.
2014-06-13 Removed !SS line from patch, made it pretty, in schematic. Added older docs that should have been added. Updated BOM with digikey part numbers.
2014-06-13 Added annotation for DEBUG-PHY-MODWIRE (currently on prototype)
2014-06-15 Added notes on manufacturing and testing.
2014-06-28 Added modwire for SPI1-NSS. This should enable the use of STM32 SPI1 in slave mode to read data output.
2014-06-29 Cleaned up modwire patches a bit. Added cuts in 0.1" double header.
2014-06-29 Whoops, fixed CLK and DATA mixup from MAX using even MORE modwires.
2014-08-24 Moved values on top of pads for easy stuffing
2014-12-17 OMG, what did I just do? GPS 4 bit output to SPI converter, in EAGLE. Not sure if it works, but somebody should prototype this.
2014-12-17 OK, I had to polish it: names, test points, header inputs/outputs, no ERC errors.
2014-12-31 First cut at monolithic GPS board for AV4: MAX2769 + COTS GPS chip (SkyTraq 638). Still TONS to do, including the CPLD the stupid MAX2769 requires.
2015-01-28 First commit of the GPS v3 board, which includes the CPLD and SkyTraq ICs.
2015-01-28 More rough drafting on the CPLD. Added 1.8V supply (kind of), added some cleanup notes on clock, etc. TODO: everything still, including cleanup up 1.8V supply and probably splitting the power domains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
2015-02-01 using the GPS Carrier from AV4, expanded the size of the board to fit in the AV4 C channel and give more room. Moved everything onto that larger board, with preliminary placement. About to rip up and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
2015-02-18 New LNA+SAW filter, plus starting to lay stuff out.
2015-02-18 library part for high speed comparator
2015-03-01 Digital portion of v3 basically laid out, RF sections laid out. To do: verify CPLD power supply, think more about ground/power separation for RF section.
2015-03-02 Added link to the MAX2769 google doc, as well as renamed things to be BOM, and committed some minor changes in the layout and notes in the schematic.
2015-03-04 Added Test Board
    Added eagle file of GPS test board for Saw Filter and LNA chip
2015-03-18 90% done! All analog routed, only 9 airwires left to the CPLD which is trivial (but should be rerouted for easy of routing and also for maybe power domains? In any case, it just needs: stiching, doub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
2015-03-18 Shrunk board to 3.0 inches (OoooooooCD!), added the beginnings of stitched vias, cleanup here and there. TODO: final conections to CPLD, then cleanup.
2015-03-18 Couldn't help myself; wired all the things. Left to do: clean-up, mostly. Verify CPLD pins, verify MAX connections and SkyTraq connections, design review, etc.
2015-03-22 More tweaks, notes, board now almost done. Still to do: 42 MHz clock, double check power plane routing, 16MHz clock cleanup.
2015-03-25 Done! Removed power split plane because that was stupid on further reflection, added clock comparator, cleaned up ERCs and DRCs.
2015-03-25 Forgot to add a few ground vias....
2015-03-25 Forgot to add comparator library earlier. Added bzillions of test points, to CPLD and STM, for future mod wires :) Also left RF class isolate to 25 mils, forgot to reset that during the last commit. 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
2015-03-25 Added part numbers to some of the odder components. Found the supercap is no longer made, so switched it to an instock item. Also checked on other components, like the LNA and splitter. Cleaned up sc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
2015-03-28 So many little tweaks: updated ground planes, created BOM and then found out that everything doesn't exist anymore, so found new part numbers and in some cases (like the supercap) found new parts, ar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
2015-03-28 OK now it's really done. tnames cleaned up more, ERC and DRC gone over, BOM updated and price calculated, found lack of stock on certain items, etc.
2015-03-28 Updated the readme
2015-03-29 Added 1.8V library, cleaned up power layer after seeing gerbers, added more comments on schematic after viewing PDF, and commited both for those folks without EAGLE.
2015-04-01 Widended interface between digital and RF sections, added spacing to high speed MAX outputs, Added THads for scope ground clips and silk area for board #. Added GPS_RESET, and cleaned up STM scehamti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
2015-04-01 We broke oshpark! So we generated gerbers. Also, glad we did, because there were errors in the solder mask in some of the library parts, now fixed.
2015-04-29 Added Xilinx docs, and changed the SAW/LNA to the *correct* part number
2015-04-29 Added notes from bring up.
2015-04-29 separate out board versions
2015-04-29 The start of better documentation.
2015-05-07 Helper scripts for setting up the Venus COTS GPS
2015-05-18 Check the bit density of max2769 samples
2015-06-08 Updated all STM32 documentation
2015-06-08 updated MAX2769 datasheet, this time with the correct chip :(
2015-06-10 Updated Schematic and BOM with problems, wrong values, etc.
2015-06-24 Updated configuration script for Venus 8
2015-06-24 Found some more recent Venus 8 docs & bins
2015-06-29 Adding notes for the state of each board
2015-07-08 Added Venus 8 AN30
2015-07-13 Set up a working Venus 8 configuration.
    We haven't found a way to get raw measurement messages, but at least
    message A8 is coming through at the desired rate.
2015-12-02 pic to the readme!
2015-12-02 Links to data
2016-01-06 More updates on the SDG GPS project, cleaned up some docs.
2016-01-06 Uh, tables? Why not?
2016-01-06 Added block diagram pic
2016-01-06 Fixed Msps number.
2016-01-06 Fix table formatting in README
2018-07-17 Add files via upload
    Adding an initial board design for a GPS Front End to be used for OreSat SDR-GPS development. Currently, there is no dedicated GPS section in the OreSat repo, so this is a temporary location.
2018-07-17 Rename Summary.md to readme.mdwn
2018-08-02 Completed, reviewed usb_gps board design.
2018-08-02 Re-add the mounting holes.
2018-10-24 schematic cleanup
2019-02-23 Create cross_repo_test.md
    Testing GitHub Pages across repos.
2019-02-23 Create default.html
    Testing GitHub Pages across repos.
2019-03-20 Moved GPS-USB front end board over to Oresat repo.
